# Keil uVision project Pro01.uvprojx, settings and files
target STM32F103R6 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_LD,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\STM32F10x_FWLib\inc;..\USER;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_ld.s
  group USER
    ../USER/: stm32f10x_it.c system_stm32f10x.c main.c
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c
